File: Tangenta/CANbus.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Fixes...
Parts:
- renumbered C178 to C105
